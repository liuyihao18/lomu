options:
  parameters:
    generate_options: qt_gui
    id: transmit_hackrf
    output_language: python
    title: transmit_hackrf
  states: {}

blocks:
- name: baseband_freq
  id: variable
  parameters:
    value: config['baseband_freq'] if config['type'] == 'single-tone' and 'baseband_freq' in config else 0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: config['center_freq']
  states: {}
- name: config
  id: json_config
  parameters:
    config_file: C:\Users\Spring\Documents\Program\GNU Radio\data\data1\config.json
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: config['fs']
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Spring\Documents\Program\GNU Radio\data\data1\data0.cf32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Spring\Documents\Program\GNU Radio\data\data1\chirp.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '2000'
    type: complex
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: hackrf=2941c2cd
    bb_gain0: '20'
    freq0: center_freq
    gain0: '11'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=25708bcd
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', network_tcp_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
